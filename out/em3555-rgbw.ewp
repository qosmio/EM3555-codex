# IAR project em3555-rgbw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EM3555 SiliconLaboratories EM3555
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3555; USE_SIMEE2; PHY_EM3XX; HAL_MICRO; BOARD_HEADER="platform/base/hal/micro/cortexm3/em35x/board/dev0680_em3555_sc3.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; APPLICATION_TOKEN_HEADER="config/app-tokens.h"; GENERATED_TOKEN_HEADER="autogen/em3555-rgbw_tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="autogen/em3555-rgbw_endpoint_config.h"; ZA_GENERATED_HEADER="autogen/em3555-rgbw.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; EMBER_APPLICATION_HAS_MAC_FILTER_MATCH_MESSAGE_HANDLER; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..; ../autogen; ../config; ../include; ../src; ../build/legacy-zigbee-stack; ../build/legacy-zigbee-stack/app/framework; ../build/legacy-zigbee-stack/app/framework/include; ../build/legacy-zigbee-stack/app/framework/util; ../build/legacy-zigbee-stack/stack; ../build/legacy-zigbee-stack/stack/include; ../build/legacy-zigbee-stack/app/util; ../build/legacy-zigbee-stack/platform/base; ../build/legacy-zigbee-stack/platform/base/hal; ../build/legacy-zigbee-stack/platform/base/hal/plugin; ../build/legacy-zigbee-stack/platform/base/hal/micro/cortexm3; ../build/legacy-zigbee-stack/platform/base/hal/micro/cortexm3/common; ../build/legacy-zigbee-stack/platform/base/hal/micro/cortexm3/em35x; ../build/legacy-zigbee-stack/platform/CMSIS/Include; ../build/legacy-zigbee-stack/platform/common/inc; ../build/legacy-zigbee-stack/platform/Device/SiliconLabs/em355x/Include; ../build/legacy-zigbee-stack/platform/radio/mac; ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin; ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin/coexistence/common; ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin/coexistence/hal/em3xx; ../build/legacy-zigbee-stack/util/silicon_labs/silabs_core
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3555; PHY_EM3XX; HAL_MICRO; BOARD_HEADER="platform/base/hal/micro/cortexm3/em35x/board/dev0680_em3555_sc3.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; APPLICATION_TOKEN_HEADER="config/app-tokens.h"; GENERATED_TOKEN_HEADER="autogen/em3555-rgbw_tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="autogen/em3555-rgbw_endpoint_config.h"; ZA_GENERATED_HEADER="autogen/em3555-rgbw.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../build/iar/debug/exe/em3555-rgbw.s37
  ILINK.IlinkOutputFile: ../build/iar/debug/exe/em3555-rgbw.out
  ILINK.IlinkIcfFile: ../build/legacy-zigbee-stack/platform/base/hal/micro/cortexm3/em35x/em3555/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../src/: app_callbacks.c app_tokens.c color_math.c debug_basic_em355x.c endpoints.c factory_reset.c ledvance_vendor.c light_state.c ota_support.c rgbw_driver_em355x.c startup_em355x_rtt.s
  group autogen
    ../autogen/: call-command-handler.c callback-stub.c bookkeeping-runtime.c znet-bookkeeping.c
  group framework
    ../build/legacy-zigbee-stack/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c multi-network.c util.c
    ../build/legacy-zigbee-stack/app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
    ../build/legacy-zigbee-stack/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../build/legacy-zigbee-stack/app/framework/plugin/basic/: basic.c
    ../build/legacy-zigbee-stack/app/framework/plugin/color-control-server/: color-control-server.c
    ../build/legacy-zigbee-stack/app/framework/plugin/general-response-commands/: general-response-commands.c
    ../build/legacy-zigbee-stack/app/framework/plugin/groups-server/: groups-server.c
    ../build/legacy-zigbee-stack/app/framework/plugin/identify/: identify.c
    ../build/legacy-zigbee-stack/app/framework/plugin/ota-common/: ota-common.c
    ../build/legacy-zigbee-stack/app/framework/plugin/ota-client/: ota-client.c ota-client-page-request.c
    ../build/legacy-zigbee-stack/app/framework/plugin/ota-storage-common/: ota-storage-common.c
    ../build/legacy-zigbee-stack/app/framework/plugin/ota-storage-simple/: ota-storage-simple.c
    ../build/legacy-zigbee-stack/app/framework/plugin/ota-bootload/: ota-bootload-soc.c
    ../build/legacy-zigbee-stack/app/framework/plugin/interpan/: interpan.c interpan-soc.c
    ../build/legacy-zigbee-stack/app/framework/plugin/level-control/: level-control.c
    ../build/legacy-zigbee-stack/app/framework/plugin/network-steering/: network-steering.c network-steering-soc.c
    ../build/legacy-zigbee-stack/app/framework/plugin/on-off/: on-off.c
    ../build/legacy-zigbee-stack/app/framework/plugin/reporting/: reporting.c reporting-default-configuration.c
    ../build/legacy-zigbee-stack/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../build/legacy-zigbee-stack/app/framework/plugin/scenes/: scenes.c
    ../build/legacy-zigbee-stack/app/framework/plugin/simple-main/: simple-main.c
    ../build/legacy-zigbee-stack/app/framework/plugin/update-tc-link-key/: update-tc-link-key.c
    ../build/legacy-zigbee-stack/app/util/common/: library.c
    ../build/legacy-zigbee-stack/app/util/security/: security-address-cache.c
    ../build/legacy-zigbee-stack/stack/config/: ember-configuration.c
    ../build/legacy-zigbee-stack/stack/framework/: ccm-star.c strong-random-api.c
  group platform
    ../build/legacy-zigbee-stack/platform/base/hal/: ember-base-configuration.c
    ../build/legacy-zigbee-stack/platform/base/hal/micro/cortexm3/: assert-crash-handlers.c bootloader-interface.c bootloader-interface-app.c button.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token.c uart.c
    ../build/legacy-zigbee-stack/platform/Device/SiliconLabs/em355x/Source/IAR/: irqToIsrTrampolines_em355x.s
    ../build/legacy-zigbee-stack/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../build/legacy-zigbee-stack/platform/base/hal/plugin/adc/: adc-em3xx.c
    ../build/legacy-zigbee-stack/platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../build/legacy-zigbee-stack/platform/base/hal/plugin/debug-jtag-stub/: debug-jtag-stub.c
    ../build/legacy-zigbee-stack/platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../build/legacy-zigbee-stack/platform/base/hal/plugin/sim-eeprom2/: sim-eeprom2.c
    ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
    ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin/coexistence/hal/em3xx/: coexistence-hal.c
    ../build/legacy-zigbee-stack/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c coulomb-counter-802154.c
  group libraries
    ../build/legacy-zigbee-stack/build/zigbee-pro-stack-cortexm3-iar-em3555-em3xx/: zigbee-pro-stack.a
    ../build/legacy-zigbee-stack/build/hal-library-cortexm3-iar-em3555-em3xx/: hal-library.a
    ../build/legacy-zigbee-stack/build/sim-eeprom2-library-cortexm3-iar-em3555-em3xx/: sim-eeprom2-library.a
    ../build/legacy-zigbee-stack/build/sim-eeprom2-1to2-upgrade-stub-library-cortexm3-iar-em3555-em3xx/: sim-eeprom2-1to2-upgrade-stub-library.a
    ../build/legacy-zigbee-stack/build/security-library-link-keys-cortexm3-iar-em3555-em3xx/: security-library-link-keys.a
    ../build/legacy-zigbee-stack/build/install-code-library-cortexm3-iar-em3555-em3xx/: install-code-library.a
    ../build/legacy-zigbee-stack/build/binding-table-library-cortexm3-iar-em3555-em3xx/: binding-table-library.a
    ../build/legacy-zigbee-stack/build/packet-validate-library-cortexm3-iar-em3555-em3xx/: packet-validate-library.a
    ../build/legacy-zigbee-stack/build/zigbee-r22-support-library-cortexm3-iar-em3555-em3xx/: zigbee-r22-support-library.a
    ../build/legacy-zigbee-stack/build/cbke-stub-library-cortexm3-iar-em3555-em3xx/: cbke-stub-library.a
    ../build/legacy-zigbee-stack/build/cbke-library-dsa-sign-stub-cortexm3-iar-em3555-em3xx/: cbke-library-dsa-sign-stub.a
    ../build/legacy-zigbee-stack/build/cbke-library-dsa-verify-stub-cortexm3-iar-em3555-em3xx/: cbke-library-dsa-verify-stub.a
    ../build/legacy-zigbee-stack/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-em3555-em3xx/: cbke-library-dsa-verify-283k1-stub.a
    ../build/legacy-zigbee-stack/build/cbke-163k1-stub-library-cortexm3-iar-em3555-em3xx/: cbke-163k1-stub-library.a
    ../build/legacy-zigbee-stack/build/cbke-283k1-stub-library-cortexm3-iar-em3555-em3xx/: cbke-283k1-stub-library.a
    ../build/legacy-zigbee-stack/build/end-device-bind-stub-library-cortexm3-iar-em3555-em3xx/: end-device-bind-stub-library.a
    ../build/legacy-zigbee-stack/build/gp-stub-library-cortexm3-iar-em3555-em3xx/: gp-stub-library.a
    ../build/legacy-zigbee-stack/build/multi-network-stub-library-cortexm3-iar-em3555-em3xx/: multi-network-stub-library.a
    ../build/legacy-zigbee-stack/build/multi-pan-stub-library-cortexm3-iar-em3555-em3xx/: multi-pan-stub-library.a
    ../build/legacy-zigbee-stack/build/source-route-stub-library-cortexm3-iar-em3555-em3xx/: source-route-stub-library.a
    ../build/legacy-zigbee-stack/build/zll-stub-library-cortexm3-iar-em3555-em3xx/: zll-stub-library.a
    ../build/legacy-zigbee-stack/build/debug-extended-stub-library-cortexm3-iar-em3555-em3xx/: debug-extended-stub-library.a
